Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: F:/BIM PGR/BIM COTTO D'ESTE/CEMENT PROJECT/KERLITE CEMENT PROJECT/Kerlite Cement Project 5Plus.ifc
Time: 2020-12-11T14:35:27
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2021 SP1 R1 (Build 568598) (64-Bit) by Vectorworks, Inc.
Made in: Windows

# IfcSite, Sito standard
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuilding, Edificio standard
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 1; IsLandmarked: no

# IfcBuildingStorey, Piano 1
In: Edificio standard
Elevation: 0 mm
Pset_BuildingStoreyCommon - EntranceLevel: no; AboveGround: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2

# IfcCovering: Laminated porcelain stoneware (UGL) (16)
In: Piano 1
Description: Porcelain stoneware tiles; PredefinedType: USERDEFINED; Material: Default
OtherThecnicalFeatures - AntibacterialProperties: Protect - test report available; ApparentDensity: 2,3 - 2,5 g/cm3; ChemicalResistance: LA, HA RESISTANT; CompressionResistance: n/a; CrazingResistance: Pass; DeepAbrasionResistance: 175mm3; DimensionsLengthAndWidth: ± 0,3 %, max ± 1 mm; DimensionsRectangularity: ± 0,3 %, max ± 1,5 mm; DimensionsStraightness: ± 0,3 %, max ± 0,8 mm; DimensionsSurfaceFlatness: ± 0,4 %, max ± 1,8 mm; DimensionsThickness: ± 5 % ± 0,5mm; ElectricalConductivity: n/a; FrostResistance: Resistant; HardnessMohsScale: n/a; ImpactResistance: n/a; Light ReflectanceValueLRV: On request; LightAndColourFastness: Pass; LinearThermalExpansion: α ≤ 7·10-6 °C-1; ModulusOfRupture: 50 N/mm2; MoistureExpansion: n/a; PhotocatalyticProperties: n/a; StainsResistance: 5 RESISTANT; SurfaceAbrasionResistance: n/a; SurfaceQuality: n/a; ThermalConductivity: 1,3 W/m °K; TotalPorosity: n/a; WaterAbsorption: 0,1%
EnvironmentalSustainability - AsbestosFreeMaterial: yes; CAMCompliantDeclaration: On request (EPD); Ecolabel UE: no; EcolabelCertification: n/a; EMASCertification/Document: https://www.cottodeste.it/download#certificazioni; EnvironmentalProductDeclarationEPD: yes; EPDDocument: On request; EPDType: Product-Specific Type III EPD; FicheDeDéclarationEnvironnementaleEtSanitaireFDESCertification: n/a; FormaldehydeFreeMaterial: yes; HealthProductDeclarationHPDCertification/self declaration: On request; ISO45001Certification: n/a; ISO50001Certification: n/a; ISO9001Certification: https://www.cottodeste.it/download#certificazioni; RawMaterialSourceAndExtractionDocument: On request; REACHCompliant: yes; RecyclableProductPackaging: yes; RecycledContentPreconsumerCertification: https://www.cottodeste.it/download#certificazioni; SolarReflectance_After3YearValue: On request; SolarReflectance_InitialValue: On request; SolarReflectanceCertification: n/a; SolarReflectanceIndexSRICertification: On request; VOCIndoorAirQualityCertification: On request; ZeroVOCMineralBasedProduct: yes
DoP&ProductCertification - BondStrengthAdhesion: NPD; BreakingStrength: ≥ 700 N; CEMarking: yes; CertificateNumber: n/a; DeclarationPerformanceNumber: DOP005EST; DurabilityExternalUseFreezeThawResistance: Passed; DurabilityForInternalUse: Passed; HarmonizedTechnicalSpecification: EN 14411:2012; Intended Use: Ceramic tiles for internal flooring and internal and external wall applications, pre-assembled on a fibreglass mesh; NameAndIdentificationNumberOfNotifiedLaboratory: n/a; ReactionToFire: Class A2–s1,d0 (wall) - Class A2fl–s1 (floor); ReleaseOfDangerousSubstanceCadmium: NPD; ReleaseOfDangerousSubstanceLead: NPD; SlipperinessBCRA_Tribometer: μ > 0,40; SlipperinessBOT3000_Tribometer: DCOF ≥ 0.42; SlipperinessBS7976-2_PendulumTester: n/a; SlipperinessDIN51097_RampBarefoot: n/a; SlipperinessDIN51131_Tribometer: n/a; SlipperinessENV12633_PendulumTester: Clase 1; SlipperinessXPCENTS16165_RampTest: n/a; SystemOfAssessmentAndVerificationOfCostancyOfPperformance: System 4; Tactility: NPD; TensileStrengthOrModulusOfRupture: 50 N/mm2; ThermalShockResistance: Pass; UNIMark: no; UNIMarkCertification: On request; UniqueIdentificationCodeOfTheProductType: Dry-pressed ceramic tiles,with water absorption Eb<0,5%
COBie_ServiceLife - ExpectedLife: 50
COBie_EconomicImpactValues - ReplacementCost: 0
COBie_Component - InstallationDate: 31/12/1900 23:59:59; WarrantyStartDate: n/a; TagNumber: n/a; AssetIdentifier: n/a
Pset_CoveringFlooring - HasNonSkidSurface: yes; HasAntiStaticSurface: no
Pset_Condition - AssessmentDate: 31/12/1900 23:59:59; AssessmentCondition: n/a; AssessmentDescription: n/a
Pset_CoveringCommon - Reference: Laminated porcelain stoneware (UGL); AcousticRating: n/a; FlammabilityRating: Class A2-s1, do (wall) ; Class A2fl-s1 (floor); FragilityRating: n/a; Combustible: no; SurfaceSpreadOfFlame: Class A; Finish: Natural Rectified; IsExternal: no; ThermalTransmittance: 236 W/K/m2; FireRating: Class A2-s1, do (wall) ; Class A2fl-s1 (floor)
COBie_Asset - AssetType: Fixed
COBie_Specification - NominalHeight: 5.5 mm; Finish: Natural Rectified; Grade: n/a; Material: Porcelain stoneware tile; Constituents: n/a; Features: n/a; AccessibilityPerformance: n/a; CodePerformance: n/a; SustainabilityPerformance: n/a
COBie_Warranty - WarrantyGuarantorParts: n/a; WarrantyDurationParts: 0; WarrantyGuarantorLabor: n/a; WarrantyDurationLabor: 0; WarrantyDescription: n/a
Pset_ManufacturerTypeInformation - GlobalTradeItemNumber: n/a; ModelReference: Kerlite Cement Project 5plus; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ProductionYear: n/a
Pset_EnvironmentalImpactIndicators - Reference: Laminated porcelain stoneware (UGL); FunctionalUnitReference: 1 mq (m2); Unit: 1 mq (m2); LifeCyclePhase: Manufacture; ExpectedServiceLife: 50 s; TotalPrimaryEnergyConsumptionPerUnit: 225; WaterConsumptionPerUnit: 0.054 m3; HazardousWastePerUnit: 0.00235 g; NonHazardousWastePerUnit: 1.62 g; ClimateChangePerUnit: 10.7 g; AtmosphericAcidificationPerUnit: 0.0254 g; RenewableEnergyConsumptionPerUnit: 46; NonRenewableEnergyConsumptionPerUnit: 179; ResourceDepletionPerUnit: 0.000075 g; InertWastePerUnit: 0 g; RadioactiveWastePerUnit: 0.00393 g; StratosphericOzoneLayerDestructionPerUnit: 0 g; PhotochemicalOzoneFormationPerUnit: 0.00232 g; EutrophicationPerUnit: 0.00358 g
Pset_EnvironmentalImpactValues - TotalPrimaryEnergyConsumption: 0; WaterConsumption: 0 m3; HazardousWaste: 0 g; NonHazardousWaste: 0 g; ClimateChange: 0 g; AtmosphericAcidification: 0 g; RenewableEnergyConsumption: 0; NonRenewableEnergyConsumption: 0; ResourceDepletion: 0 g; InertWaste: 0 g; RadioactiveWaste: 0 g; StratosphericOzoneLayerDestruction: 0 g; PhotochemicalOzoneFormation: 0 g; Eutrophication: 0 g; LeadInTime: 0; Duration: 0; LeadOutTime: 0
Pset_ServiceLife - ServiceLifeDuration: 50; MeanTimeBetweenFailure: n/a
Pset_Warranty - WarrantyIdentifier: n/a; WarrantyStartDate: 31/12/1900 23:59:59; WarrantyEndDate: 31/12/1900 23:59:59; IsExtendedWarranty: no; WarrantyPeriod: n/a; WarrantyContent: n/a; PointOfContact: n/a; Exclusions: n/a
COBie - BarCode: n/a; Category: Pr_35_93_96_19:Ceramic tiles; Description: Concrete Effect; DurationUnit: Year; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ModelNumber: n/a; ModelReference: Kerlite Cement Project 5plus; SerialNumber: n/a; WarrantyDurationUnit: Year
Name | SlipperinessDIN51130_RampWithOil | UPECmark | UPECMarkCertification | NominalLength (mm) | NominalWidth (mm) | Shape | Size | Color = ModelLabel | ArticleNumber | Name
Kerlite Cement project 5plus Color 00 CEM Nat Ret 100x300 | R9 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 00 CEM | EK7CP80 | Color 00 CEM Nat Ret 100x300
Kerlite Cement project 5plus Color 00 CEM Nat Ret 100x100 | R9 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | 1000 | 1000 | Square | 1000x1000x5.5 mm | color 00 CEM | EK8CP80 | Color 00 CEM Nat Ret 100x100
Kerlite Cement project 5plus Color 10 CEM Nat Ret 100x300 | R9 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 10 CEM | EK7CP50 | Color 10 CEM Nat Ret 100x300
Kerlite Cement project 5plus Color 10 CEM Nat Ret 100x100 | R9 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | 1000 | 1000 | Square | 1000x1000x5.5 mm | color 10 CEM | EK8CP50 | Color 10 CEM Nat Ret 100x100
Kerlite Cement project 5plus Color 10 WORKNat Ret 100x300 | R10 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 10 WORK | EK7CP10 | Color 10 WORK Nat Ret 100x300
Kerlite Cement project 5plus Color 10 WORK Nat Ret 50X150 | R10 | no | n/a | 500 | 1500 | Rectangular | 500x1500x5.5 mm | color 10 WORK | EK0CP10 | Color 10 WORK Nat Ret 50x150
Kerlite Cement project 5plus Color 20 CEM Nat Ret 100x300 | R9 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 20 CEM | EK7CP60 | Color 20 CEM Nat Ret 100x300
Kerlite Cement project 5plus Color 20 CEM Nat Ret 100x100 | R9 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | 1000 | 1000 | Square | 1000x1000x5.5 mm | color 20 CEM | EK8CP60 | Color 20 CEM Nat Ret 100x100
Kerlite Cement project 5plus Color 20 WORK Nat Ret 100x300 | R10 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 20 WORK | EK7CP20 | Color 20 WORK Nat Ret 100x300
Kerlite Cement project 5plus Color 20 WORK Nat Ret 50X150 | R10 | no | n/a | 500 | 1500 | Rectangular | 500x1500x5.5 mm | color 20 WORK | EK0CP20 | Color 20 WORK Nat Ret 50x150
Kerlite Cement project 5plus Color 30 CEM Nat Ret 100x300 | R9 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 30 CEM | EK7CP70 | Color 30 CEM Nat Ret 100x300
Kerlite Cement project 5plus Color 30 CEM Nat Ret 100x100 | R9 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | 1000 | 1000 | Square | 1000x1000x5.5 mm | color 30 CEM | EK8CP70 | Color 30 CEM Nat Ret 100x100
Kerlite Cement project 5plus Color 30 WORK Nat Ret 100x300 | R10 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 30 WORK | EK7CP30 | Color 30 WORK Nat Ret 100x300
Kerlite Cement project 5plus Color 30 WORK Nat Ret 50X150 | R10 | no | n/a | 500 | 1500 | Rectangular | 500x1500x5.5 mm | color 30 WORK | EK0CP30 | Color 30 WORK Nat Ret 50x150
Kerlite Cement project 5plus Color 40 CEM Nat Ret 100x300 | R9 | no | n/a | 3000 | 1000 | Rectangular | 3000x1000x5.5 mm | color 40 CEM | EK7CP90 | Color 40 CEM Nat Ret 100x300
Kerlite Cement project 5plus Color 40 CEM Nat Ret 100x100 | R9 | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | 1000 | 1000 | Square | 1000x1000x5.5 mm | color 40 CEM | EK8CP90 | Color 40 CEM Nat Ret 100x100
